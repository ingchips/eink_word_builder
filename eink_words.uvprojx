# Keil uVision project eink_words.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: ING91800 INGChips
  pack: INGChips.INGCHIPS_DeviceFamilyPack.0.9.0
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M3") ELITTLE IROM(0x4000-0x43fff) IRAM(0x20000000-0x2000ffff)
  output: eink_words +hex
  AfterMake: fromelf.exe --bin -o eink_words.bin ./output/eink_words.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ../../sdk/bundles/typical/inc;../../sdk/bundles/typical/inc/os;../../sdk/src/BSP;../../sdk/src/FWlib;../../sdk/src/StartUP/ing918;../../sdk/src/Tools;../../sdk/src
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5e000
  memory RVCT9: RAM 0x20007910 size 0x86f0
  group APP
    ./src/: main.c profile.c mmc_spi.c
  group StartUP
    ./src/: startup_ing91800.s
    ../../sdk/bundles/typical/ING9187xx/: symdefs.m
  group FWlib
    ../../sdk/src/FWlib/: peripheral_uart.c peripheral_pinctrl.c peripheral_sysctrl.c peripheral_timer.c peripheral_ssp.c peripheral_gpio.c peripheral_rtc.c
  group Tools
    ../../sdk/src/Tools/: trace.c
  group epaper
    ./src/epaper/: epd.c EPD_1in54.c EPD_1in54_V2.c EPD_1in54_V3.c EPD_1in54b.c EPD_1in54b_V2.c EPD_1in54c.c Dev_Config.c
  group fatfs
    ./fatfs/: ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 4.3.0
